## Kconfig
```kconfig
config RTL8189ES
	tristate "Realtek 8189E SDIO WiFi"
	depends on WLAN && MMC
	select WIRELESS_EXT
	select WEXT_PRIV
	---help---
	  Help message of RTL8189ES
```
